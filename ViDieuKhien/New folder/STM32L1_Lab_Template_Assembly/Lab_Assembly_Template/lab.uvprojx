# Keil uVision project lab.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L152RC STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lab +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: core_cm3_constant.s startup_stm32l1xx_md.s stm32l1xx_constants.s stm32l1xx_tim_constants.s
    D:/Tren_Lop/ki_2_2018-2019/ViDieuKhien/: main.s
software components: CMSIS:CORE 3.40.0
